Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-06-09T10:29:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 09 10:29:34 2021 * Host: ws-118 * Database: C:\Users\RYAN~1.LAS\AppData\Local\Temp\{2FBBD85E-4C6B-45BF-96D8-C4E1349458A8}\ifc * Database version: 5507 * Database creation date: Wed Jun 09 10:29:33 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 09 10:29:34 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 09 10:29:34 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: Neo Modern Close Coupled Toilet, AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST):Neo Modern Close Coupled Toilet:4157
In: Level 1
Classification: C1030200 (Uniformat); Material: Chrome, Plastic - White, Porcelain - White
Pset_ManufacturerTypeInformation - ModelReference: Neo Modern Close Coupled Toilet; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Neo Modern Close Coupled Toilet
Constraints - Elevation: 0 mm
Construction - ToiletBowlHole: yes; ToiletLidTop: no
Dimensions - Area: 0.856307 m2; Volume: 0.119366 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary,Domestic Cold Water
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST): Neo Modern Close Coupled Toilet; Family and Type: AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST): Neo Modern Close Coupled Toilet; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST): Neo Modern Close Coupled Toilet; Type Id: AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST): Neo Modern Close Coupled Toilet; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: Floor Mounted; ProductCategory: Fixtures & Vanities (10); ProductGroup: WC Close Coupled (02); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Chinaware/Ceramics (WC) (11)
Identity Data(Type) - Assembly Code: C1030200; Description: Neo Modern Close Coupled Toilet; Keynote: N13; Manufacturer: American Standard; Model: Neo Modern Close Coupled Toilet; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: CL26305-6DACTST; Type Name: Neo Modern Close Coupled Toilet; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/cl26305-6dactst/document/object-user-guide; BIMObjectName: AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST); NBSDescription: WC pans; NBSNote: n/a; NBSObjectName: American Standard - WC pans; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/360
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_96_18; CodePerformance: n/a; Color: White; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/cl26305-6dactst/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/cl26305-6dactst/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/cl26305-6dactst/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/cl26305-6dactst/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/cl26305-6dactst/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: AmericanStandard_WCCloseCoupled_NeoModern_(CL26305-6DACTST); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: Vitreous China; ModelNumber: CL26305-6DACTST; ModelReference: Neo Modern Close Coupled Toilet; ProductionYear: 2021; ReferencedStandard: TIS 792-2011;PNS 993:2000;MS 1522:2015;SS 378-1996;GB 6952-2015; ReplacementCost: n/a; Shape: n/a; Size: L710 x W376 x H792 mm; TypeName: Neo Modern Close Coupled Toilet; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
